# Keil uVision project SPI&USB-Receive.uvproj, settings and files
target SPI&USB_Receive (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SPI&USB-Receive +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\Library\CMSIS\CM3\CoreSupport;.\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Library\STM32F10x_StdPeriph_Driver\inc;.\Library\STM32F10x_StdPeriph_Driver\src;.\User;.\User\NRF24L01;.\User\USB;.\USB_Library\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group NRF24L01
    ./User/NRF24L01/: 24l01.c usart.c
  group USB
    ./User/USB/: hw_config.c led.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c usb_endp.c
  group Startup
    ./Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ./Library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Library
    ./Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c
  group USB_Library
    ./USB_Library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
