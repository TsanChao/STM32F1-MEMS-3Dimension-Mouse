# Keil uVision project Mouse.uvproj, settings and files
target Mouse_Send (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Mouse +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\User\inc;..\Library\CMSIS\CM3\CoreSupport;..\Library\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Library\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/src/: main.c stm32f10x_it.c data_convert.c
  group Sensor
    ../User/src/: accelerometer.c gyroscope.c magnetometer.c calibration.c
  group Periph_Device
    ../User/src/: analog_iic.c usart.c timer.c 24l01.c key.c delay.c
  group Attitude
    ../User/src/: AHRS_matrix.c AHRS_quat.c AHRS_states.c
  group Startup
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Library/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Library
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_exti.c
